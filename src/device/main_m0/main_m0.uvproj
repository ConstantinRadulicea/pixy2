# Keil uVision project main_m0.uvproj, settings and files
target main_m0 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: m0 +hex
  AfterMake: fromelf --cadcombined --output="m0_image.c" ".\m0\m0.axf"
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3
  c define: CORE_M0  IPC_SLAVE PIXY KEIL
  c include: ., ..\libpixy_m0\inc, .\inc, ..\..\common\inc, ..\common\inc, inc
  asm define: NO_CRP  IPC_SLAVE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x2000 size 0x2000
  group Source Code
    ./src/: main_m0.c startup_LPC43xx_m0.s equeue.c
    ../libpixy_m0/: libpixy_m0.lib
