# Keil uVision project main_m4.uvprojx, settings and files
target Flash (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: LPC4330:Cortex-M0 NXP
  pack: Keil.LPC4300_DFP.2.10.2
  cpu: IRAM(0x10000000,0x20000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: main_m4
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\inc;..\common\inc;..\common\src;..\..\common\inc;..\..\common\src
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Code
    ./src/: analogdig.cpp button.cpp conncomp.cpp exec.cpp i2c.cpp progblobs.cpp progvideo.cpp serial.cpp spi.cpp uart.cpp main_m4.cpp progpt.cpp progline.cpp line.cpp equeue.cpp spi2.cpp
    ../../common/src/: blob.cpp blobs.cpp colorlut.cpp qqueue.cpp
    ../libpixy_m4/: libpixy_m4.lib
target RAM (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: main_m4 +hex
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: CORE_M4 IPC_MASTER PIXY KEIL
  c include: ., inc, ..\libpixy_m4\inc, ..\..\common\inc, ..\common\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ram.sct
software components: CMSIS:CORE 6.1.0
